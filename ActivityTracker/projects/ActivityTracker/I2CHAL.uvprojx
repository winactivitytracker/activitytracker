# Keil uVision project I2CHAL.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: I2CHAL
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F030C8Tx/STCubeGenerated/Src/: main.c stm32f0xx_it.c
    ./RTE/Device/STM32F030C8Tx/STCubeGenerated/Inc/: stm32f0xx_it.h
software components: CMSIS:CORE 5.4.0, Device:STM32Cube HAL 1.11.0
